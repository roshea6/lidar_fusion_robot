Commit message: Committing everything in case I lose my linux partition

File: urdf/twin_lidar.urdf (robot description, URDF)
Before this commit: robot twin_lidar_robot, 3 links, 2 joints
Links:
- link base_link: geometry collision box size=2.0 4.0 .5; visual box size=1.0 2.0 .5
